# Keil uVision project A&D_v3.uvprojx, settings and files
target A&D (ARM-ADS)
  device: STM32F303VC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) IRAM2(0x10000000,0x2000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: A&D_v3 +hex
  c flags: Optim=1 wLevel=2
  c include: ..\Src;..\Drivers\STD\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group User
    ../Src/: main.c init.c
  group SPL
    ../Drivers/STD/src/: stm32f30x_dma.c stm32f30x_exti.c stm32f30x_gpio.c stm32f30x_i2c.c stm32f30x_misc.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_rtc.c stm32f30x_spi.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_usart.c
  group ::Board Support
    C:/Keil_v5/ARM/PACK/Keil/STM32F3xx_DFP/1.1.0/Boards/ST/STM32F3-Discovery/Common/: LED_STM32F3-Discovery.c
  group ::CMSIS
    C:/Keil_v5/ARM/PACK/ARM/CMSIS/4.2.0/CMSIS_RTX/LIB/ARM/: RTX_CM4.lib
    RTE/CMSIS/: RTX_Conf_CM.c
  group ::Device
    RTE/Device/STM32F303VC/: startup_stm32f303xc.s system_stm32f30x.c
software components: CMSIS:CORE 3.40.0, CMSIS:RTOS:Keil RTX 4.75.0, Board Support:LED 1.0.0, Device:Startup 1.2.0
